description = "Builds the OPOS kernel"
PR = "r1"
DEFAULT_PREFERENCE = "0"

do_build() {
	echo "Building the OPOS kernel..."
	ARCH=$()
}


do_clean() {
           echo "Cleaning the OPOS kernel directory..."
}